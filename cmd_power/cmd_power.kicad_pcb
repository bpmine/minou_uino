# Repository bpmine/minou_uino

File README.md:

# minou_uino - Domotique pour la cabane du minou

Les programmes de cette base gèrent la cabane de notre minou (voir images suivantes).

## Datalogger

Le premier projet est un datalogger pour relever les temperatures et humidités à différents emplacements de la cabane.

Il pilotait également deux bandeaux à LEDs et un éclairage intérieur.

## Eclairage de la tour

Le second projet est un eclairage de la tour piloté par Wifi.

Un connecteur logiciel permet d'interragir avec la tour dans le jeu minetest. Par exemple, lorsqu'un joueur casse un bloc, les LEDs deviennent rouge.

## Cabane connectee

Le prochain projet sera de remplacer le datalogger par une carte wifi.

On pourra piloter les LEDs de la cabane et relever les valeurs des capteurs par le réseau.

## KiCad design cmd_power/cmd_power.kicad_pcb

Parts:
C1: 1000µF; CP_Radial_D16.0mm_P7.50mm
C2, C4, C5, C6: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3: 20µ; CP_Radial_D4.0mm_P2.00mm
D1: SR1060; D_DO-15_P12.70mm_Horizontal
D2: 6A10; D_DO-201AD_P12.70mm_Horizontal
D3: 1N5822; D_A-405_P10.16mm_Horizontal
D4: P6KE18A; D_DO-201AD_P12.70mm_Horizontal
D5, D6: 1N4744A; D_DO-41_SOD81_P10.16mm_Horizontal
D7, D8, D9: LED; LED_D3.0mm
F1: 7A; Fuseholder_TR5_Littelfuse_No560_No460
F2: 500mA; Fuseholder_TR5_Littelfuse_No560_No460
J1: Alim 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J2: Output 12V/500mA; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J3: Chauffage 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J4: Ventil 12V; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J5: Cmds; TerminalBlock_Phoenix_MPT-0,5-4-2.54_1x04_P2.54mm_Horizontal
NT1: NetTie_2; NetTie-2_SMD_Pad2.0mm
Q2, Q5: P03P4L-04; TO-220-3_Vertical
Q4: BC557; TO-92_Inline
R1, R4: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3, R7, R8: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5: 5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6: 30; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
X1, X2, X3, X4: Trou; BPC_Trou4mm_Fixation

Connections:
CMD_CHAUFFAGE: J5.1, R2.1
CMD_VENTIL: D6.2 (A), J5.3, R4.2, R5.1
GND: C2.2, C3.2, C6.1, D7.1 (K), D9.1 (K), J2.2, J4.2, J5.2, J5.4, NT1.1
GNDPWR: C1.2, C4.1, C5.2, D4.1 (A1), D8.1 (K), J1.2, J3.1, NT1.2
unnamed: D1.2 (A), J1.1
unnamed: D1.1 (K), F1.2, F2.2
unnamed: C4.2, D2.2 (A), J3.2, Q2.2 (D), R7.1
unnamed: C6.2, D3.2 (A), J4.1, Q5.2 (D), R3.1
unnamed: D3.1 (K), Q4.2 (B), Q5.3 (S), R6.1
unnamed: D5.2 (A), Q2.1 (G), R1.2, R2.2
unnamed: D7.2 (A), R3.2
unnamed: D8.2 (A), R7.2
unnamed: D9.2 (A), R8.2
unnamed: Q4.1 (C), Q5.1 (G), R5.2
POWER_12V: C1.1, C5.1, D2.1 (K), D4.2 (A2), D5.1 (K), F1.1, Q2.3 (S), R1.1, R8.1
SMALL_12V: C2.1, C3.1, D6.1 (K), F2.1, J2.1, Q4.3 (E), R4.1, R6.2

Notes on the sheet:
Ou IRF4905
120mA

Board: 2 copper layers, 64.0 x 64.0 mm, 38 parts (4 on the bottom side), 16 nets.

## KiCad design cmd_tapis/cmd_tapis.kicad_pcb

Board: 2 copper layers, 64.0 x 64.0 mm, 15 parts (1 on the bottom side), 8 nets.

Parts:
C1: 20µF; CP_Radial_D5.0mm_P2.50mm
C2: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1, D3: 1N5818; D_A-405_P10.16mm_Horizontal
D2: LED; LED_D3.0mm
F1: 10A; Fuseholder_TR5_Littelfuse_No560_No460
J1: Cmd_12V; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J2: IN_230V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J3: OUT_230V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
R1: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RL1: BPC_G2RL-1-DC12; BPC_Relay_SPDT_Omron_G2RL-1-E
X1, X2, X3, X4: Trou; BPC_Trou4mm_Fixation

Connections:
GND: C1.2, C2.2, D1.2 (A), D2.1 (K), J1.2, RL1.8
unnamed: C1.1, C2.1, D1.1 (K), D3.1 (K), R1.1, RL1.1
unnamed: D2.2 (A), R1.2
unnamed: D3.2 (A), J1.1
unnamed: F1.2, RL1.3, RL1.6
unnamed: J2.1, J3.2
unnamed: F1.1, J2.2
unnamed: J3.1, RL1.4, RL1.5

## KiCad design cabane_minou/cabane_minou/cabane_minou.kicad_pcb

File cabane_minou/readme.md:

# CABANE MINOU 2 - Pilotage par Wifi

C'est la deuxième version de la carte de contrôle de la cabane de minou.
Cette fois-ci, elle est accessible par Wifi.

## Interface E/S

### Bornier

Num | Type | Port|Description
--|--|--|--
1|Alim||Masse
2|Entrée|D12|Température extérieure DH11 (Voir aussi J3)
3|Entrée|D11|Mouvement en bas 
4|Entrée|D7|Température en bas DH11
5|Sortie|D6|Bandeau de LEDs du Haut
6|Entrée|D5|Capot
7|Sortie|D4|LED blanche du bas
8|Sortie|D2|Bandeau de LEDs du bas
9|Entrée|D1|Mouvement en haut
10|Alim||5V

*NB:* L'entrée 2 n'est pas connectée car elle est dispo sur le picot J3 de la carte.

```c
#define PIN_DARK          A0

#define PIN_MOVE_HAUT     D1
#define PIN_DATA_LED_BAS  D2 
#define PIN_LED_BAS       D4
#define PIN_CAPOT         D5
#define PIN_DATA_LED_HAUT D6
#define PIN_DHT11_BAS     D7

#define PIN_MOVE_BAS      9
#define PIN_DHT11_OUT     10
```

## Fonctionnalités

- Bandeau

Parts:
D5, D6, D7, D8, D10, D11, D12, D13, D14, D15, D16, D17: DO-204; D_A-405_P2.54mm_Vertical_AnodeUp
D9: DO-201; D_5W_P12.70mm_Horizontal
J4: Bas; TerminalBlock_Phoenix_PT-1,5-5-3.5-H_1x05_P3.50mm_Horizontal
J5: LEDs Bas; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J6: Move Tour; TerminalBlock_Phoenix_PT-1,5-4-3.5-H_1x04_P3.50mm_Horizontal
J7: LEDs Tour; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J8: Move Haut; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J9: LEDs Haut; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J10: Serial; TerminalBlock_Phoenix_PT-1,5-4-3.5-H_1x04_P3.50mm_Horizontal
J11: LEDs Res; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J12: Leds; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
J13: Buttons; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
J14: Couvercle; JST_EH_B6B-EH-A_1x06_P2.50mm_Vertical
J15: Commande 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
Q5: BPC_2N2222A; TO-92; Manufacturer_Part_Number 2N2222A; Mouser Part Number 494-2N2222A
Q6: BPC_IPP034N03L; TO-220-3_Vertical
R13, R15, R16, R18, R20: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R14, R17, R19, R21, R24, R26, R27, R32, R33, R34, R35, R36, R37, R38, R39: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R22, R23, R28, R29, R30, R31: 10; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R25: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
5V_LEDS_BAS: J5.1; also elsewhere on the board
5V_LEDS_HAUT: J9.1; also elsewhere on the board
5V_LEDS_RES: J11.1; also elsewhere on the board
5V_LEDS_TOUR: J7.1; also elsewhere on the board
5V_SER: J10.1; also elsewhere on the board
+5V: D5.1 (K), D7.1 (K), D10.1 (K), D12.1 (K), D14.1 (K), D16.1 (K), J4.1, J6.1, J8.1, J14.1, R14.1, R17.1, R19.1, R26.1, R27.1, R32.1, R34.1, R36.1, R38.1; also elsewhere on the board
GND: D6.2 (A), D8.2 (A), D11.2 (A), D13.2 (A), D15.2 (A), D17.2 (A), J4.6, J5.3, J6.4, J7.3, J8.3, J9.3, J10.4, J11.3, J12.3, J13.3, J14.6, J15.2, Q5.1, R21.2, R33.2, R35.2, R37.2, R39.2; also elsewhere on the board
IN_CAPOT: J4.3, R25.1
IN_PRESENCE_BAS: J4.5, R29.1
IN_PRESENCE_HAUT: J8.2, R28.2
IN_PRESENCE_TOUR_BAS: J6.2, R31.2
IN_PRESENCE_TOUR_HAUT: J6.3, R30.2
LUMINOSITE: D7.2 (A), D8.1 (K), J14.3, R26.2; also elsewhere on the board
unnamed: D9.2 (A), J15.1, Q6.3 (S)
unnamed: J12.1, R15.1
unnamed: J12.2, R16.1
unnamed: J14.5, R18.1
unnamed: Q5.2, R20.2, R21.1
unnamed: Q5.3, Q6.1 (G), R24.2
OUT_LEDS_BAS: J5.2; also elsewhere on the board
OUT_LEDS_HAUT: J9.2; also elsewhere on the board
OUT_LEDS_RES: J11.2; also elsewhere on the board
OUT_LEDS_TOUR: J7.2; also elsewhere on the board
OUT_LED_CAPOT_OUVERT: J4.2, R13.1
POWER_12V: D9.1 (K), Q6.2 (D), R24.1; also elsewhere on the board
TEMP_BAS: J4.4, R22.2
TEMP_EXT: J14.2, R23.2
UC_IN_CAPOT: D5.2 (A), D6.1 (K), R25.2, R27.2; also elsewhere on the board
UC_IN_PRESENCE_BAS: D12.2 (A), D13.1 (K), R29.2, R34.2, R35.1; also elsewhere on the board
UC_IN_PRESENCE_HAUT: D10.2 (A), D11.1 (K), R28.1, R32.2, R33.1; also elsewhere on the board
UC_IN_PRESENCE_TOUR_BAS: D16.2 (A), D17.1 (K), R31.1, R38.2, R39.1; also elsewhere on the board
UC_IN_PRESENCE_TOUR_HAUT: D14.2 (A), D15.1 (K), R30.1, R36.2, R37.1; also elsewhere on the board
UC_IN_SW1_BUTTON: J14.4, R14.2; also elsewhere on the board
UC_IN_SW2_BUTTON: J13.1, R17.2; also elsewhere on the board
UC_IN_SW3_BUTTON: J13.2, R19.2; also elsewhere on the board
UC_OUT_CMD_CHAUFFAGE: R20.1; also elsewhere on the board
UC_OUT_LED_1: R18.2; also elsewhere on the board
UC_OUT_LED_2: R15.2; also elsewhere on the board
UC_OUT_LED_3: R16.2; also elsewhere on the board
UC_OUT_LED_CAPOT_OUVERT: R13.2; also elsewhere on the board
UC_RX_SER: J10.2; also elsewhere on the board
UC_TEMP_BAS: R22.1; also elsewhere on the board
UC_TEMP_EXT: R23.1; also elsewhere on the board
UC_TX_SER: J10.3; also elsewhere on the board

Notes on the sheet:
Haut
Tour
Bas

Parts:
C1, C3, C8: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: 40uF; CP_Radial_D8.0mm_P3.80mm
C4: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5: 1n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C6: 20uF; CP_Radial_D8.0mm_P3.80mm
C7: 10µF; CP_Radial_D4.0mm_P2.00mm
D1: SR560; D_DO-15_P12.70mm_Horizontal
D2, D3: DO-204; D_A-405_P2.54mm_Vertical_AnodeUp
J1: Alim 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
Q1, Q3: BPC_2N2222A; TO-92; Manufacturer_Part_Number 2N2222A; Mouser Part Number 494-2N2222A
Q2, Q4: BC327; TO-92_Inline
R1, R6: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3, R4, R7, R8: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5: 30k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
TH1: Thermistor_NTC; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: BPC_Alim5V
U2: LM1117DT-3.3; TO-220-3_Vertical

Connections:
5V_SER: Q4.1 (C); also elsewhere on the board
12V: C2.1, C3.1, R4.1, TH1.2, U1.1 (IN+), U1.2 (IN+)
+5V: C5.1, C6.1, D2.1 (K), Q2.3 (E), Q4.3 (E), R3.1, R8.1, U1.7 (OUT+), U1.8 (OUT+); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D3.2 (A), J1.2, Q1.1, Q3.1, R2.2, R5.2, R7.2, U1.3 (IN-), U1.4 (IN-), U1.5 (OUT-), U1.6 (OUT-), U2.1 (GND); also elsewhere on the board
unnamed: C1.1, Q1.2, R1.2, R2.1
unnamed: C8.1, Q3.2, R6.2, R7.1
unnamed: D1.2 (A), J1.1
unnamed: Q1.3, Q2.2 (B), R3.2
unnamed: C4.1, Q2.1 (C), U2.3 (VI)
unnamed: Q3.3, Q4.2 (B), R8.2
POWER_3.3: C7.1, U2.2 (VO); also elsewhere on the board
POWER_12V: D1.1 (K), TH1.1; also elsewhere on the board
UC_3V_ESP: R1.1; also elsewhere on the board
UC_5V_SER: R6.1; also elsewhere on the board
UC_IN_MES_12V: D2.2 (A), D3.1 (K), R4.2, R5.1; also elsewhere on the board

Notes on the sheet:
Verif pinout micro = schéma = empreinte Verif EN du buffer et aussi son empreinte

Parts:
C21, C22, C23, C24: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
Q7, Q8, Q11, Q12: BPC_2N2222A; TO-92; Manufacturer_Part_Number 2N2222A; Mouser Part Number 494-2N2222A
Q9, Q10, Q13, Q14: BC327; TO-92_Inline
R40, R41, R50, R51: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R42, R43, R44, R45, R52, R53, R54, R55: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R46, R47, R48, R49: 50; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
5V_LEDS_BAS: Q10.1 (C); also elsewhere on the board
5V_LEDS_HAUT: Q9.1 (C); also elsewhere on the board
5V_LEDS_RES: Q14.1 (C); also elsewhere on the board
5V_LEDS_TOUR: Q13.1 (C); also elsewhere on the board
+5V: Q9.3 (E), Q10.3 (E), Q13.3 (E), Q14.3 (E), R44.1, R45.1, R54.1, R55.1; also elsewhere on the board
GND: C21.2, C22.2, C23.2, C24.2, Q7.1, Q8.1, Q11.1, Q12.1, R42.2, R43.2, R52.2, R53.2; also elsewhere on the board
unnamed: C21.1, Q7.2, R40.2, R42.1
unnamed: C22.1, Q8.2, R41.2, R43.1
unnamed: C23.1, Q11.2, R50.2, R52.1
unnamed: C24.1, Q12.2, R51.2, R53.1
unnamed: Q7.3, Q9.2 (B), R44.2
unnamed: Q8.3, Q10.2 (B), R45.2
unnamed: Q11.3, Q13.2 (B), R54.2
unnamed: Q12.3, Q14.2 (B), R55.2
OUT_LEDS_BAS: R46.2; also elsewhere on the board
OUT_LEDS_HAUT: R47.2; also elsewhere on the board
OUT_LEDS_RES: R49.2; also elsewhere on the board
OUT_LEDS_TOUR: R48.2; also elsewhere on the board
UC_5V_LEDS_BAS: R41.1; also elsewhere on the board
UC_5V_LEDS_HAUT: R40.1; also elsewhere on the board
UC_5V_LEDS_RES: R51.1; also elsewhere on the board
UC_5V_LEDS_TOUR: R50.1; also elsewhere on the board
UC_OUT_LEDS_BAS: R46.1; also elsewhere on the board
UC_OUT_LEDS_HAUT: R47.1; also elsewhere on the board
UC_OUT_LEDS_RES: R49.1; also elsewhere on the board
UC_OUT_LEDS_TOUR: R48.1; also elsewhere on the board
