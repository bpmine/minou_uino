# Repository bpmine/minou_uino (continued)

## KiCad design cabane_minou/cabane_minou/cabane_minou.kicad_pcb (continued)

Parts:
C9, C13: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C10, C14: 10µF; CP_Radial_D4.0mm_P2.00mm
C11, C15: 10uF; CP_Radial_D4.0mm_P2.00mm
C12, C16, C17, C18, C19: 1n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C20: 20uF; CP_Radial_D8.0mm_P3.80mm
D4: D; D_5W_P12.70mm_Horizontal
J2: Log; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Screen; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R9, R10: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R11, R12: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U3: BPC_ATMEGA2560_PRO; BPC_ATMEGA2560_PRO_MINI; PARTREV 12/May/2017
U4: BPC_HC05_Vertical
U5: RtcArduino; BPC_RtcArduino
U6: BPC_ESP8266-01_ESP-01; BPC_XCVR_ESP8266-01_ESP-01; PARTREV V1.2
U7: BPC_LVLCONV_5_33
X1, X2, X3, X4: Trou; BPC_Trou4mm_Fixation

Connections:
+5V: C9.1, C10.1, C13.1, C14.1, C18.1, D4.2 (A), J2.1, J3.1, R11.1, R12.1, U4.2 (Vcc), U5.2 (VCC), U7.10 (HV); also elsewhere on the board
ESP_RX_3: U6.4 (RXD), U7.5 (LV3)
ESP_TX_3: U6.5 (TXD), U7.6 (LV4)
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C19.2, C20.2, J2.4, J3.4, U3.GND_1 (GND), U3.GND_2 (GND), U3.GND_3 (GND), U4.3 (Gnd), U5.1 (GND), U6.1 (GND), U7.4 (GND), U7.9 (GND); also elsewhere on the board
IO1_3: U6.3 (IO0), U7.1 (LV1)
IO2_3: U6.2 (IO2), U7.2 (LV2)
LUMINOSITE: U3.A14; also elsewhere on the board
unnamed: C11.1, C12.1, C15.1, C17.1, D4.1 (K), U3.5V_1 (5V), U3.5V_2 (5V), U3.5V_3 (5V)
unnamed: R10.1, U4.5 (RXD)
unnamed: R9.2, U4.4 (TXD)
POWER_3.3: C16.2, C19.1, C20.1, U6.8 (VCC), U7.3 (LV); also elsewhere on the board
SCL: J3.2, R11.2, U3.D21, U5.4 (SCL)
SDA: J3.3, R12.2, U3.D20, U5.3 (SDA)
UC_3V_ESP: U3.D41; also elsewhere on the board
UC_5V_LEDS_BAS: U3.D30; also elsewhere on the board
UC_5V_LEDS_HAUT: U3.D28; also elsewhere on the board
UC_5V_LEDS_RES: U3.D26; also elsewhere on the board
UC_5V_LEDS_TOUR: U3.D22; also elsewhere on the board
UC_5V_SER: U3.D24; also elsewhere on the board
UC_ESP_RX: U3.D19, U7.7 (HV4)
UC_ESP_TX: U3.D18, U7.8 (HV3)
UC_IN_CAPOT: U3.D32; also elsewhere on the board
UC_IN_MES_12V: U3.A15; also elsewhere on the board
UC_IN_PRESENCE_BAS: U3.D36; also elsewhere on the board
UC_IN_PRESENCE_HAUT: U3.D27; also elsewhere on the board
UC_IN_PRESENCE_TOUR_BAS: U3.D37; also elsewhere on the board
UC_IN_PRESENCE_TOUR_HAUT: U3.D39; also elsewhere on the board
UC_IN_SW1_BUTTON: U3.D40; also elsewhere on the board
UC_IN_SW2_BUTTON: U3.D3; also elsewhere on the board
UC_IN_SW3_BUTTON: U3.D5; also elsewhere on the board
UC_IO1: U3.D7, U7.12 (HV1)
UC_IO2: U3.D9, U7.11 (HV2)
UC_OUT_CMD_CHAUFFAGE: U3.D2; also elsewhere on the board
UC_OUT_LEDS_BAS: U3.D31; also elsewhere on the board
UC_OUT_LEDS_HAUT: U3.D29; also elsewhere on the board
UC_OUT_LEDS_RES: U3.D25; also elsewhere on the board
UC_OUT_LEDS_TOUR: U3.D23; also elsewhere on the board
UC_OUT_LED_1: U3.D43; also elsewhere on the board
UC_OUT_LED_2: U3.D4; also elsewhere on the board
UC_OUT_LED_3: U3.D6; also elsewhere on the board
UC_OUT_LED_CAPOT_OUVERT: U3.D34; also elsewhere on the board
UC_RX_LOG: J2.3, U3.D17
UC_RX_PROG: R9.1, U3.RX
UC_RX_SER: U3.D15; also elsewhere on the board
UC_TEMP_BAS: U3.D38; also elsewhere on the board
UC_TEMP_EXT: U3.D42; also elsewhere on the board
UC_TX_LOG: J2.2, U3.D16
UC_TX_PROG: R10.2, U3.TX
UC_TX_SER: U3.D14; also elsewhere on the board

Notes on the sheet:
Diode pour protéger quand USB branché sur le module
1 cmd Alim module croquettes 1 cmd moteur croquettes 1 cmd vibreur croquettes 1 detecteur croquettes vides 1 cmd pompe eau fontaine 1 cmd LED fontaine

Board: 2 copper layers, 140.0 x 120.1 mm, 137 parts (11 on the bottom side), 88 nets.

## Code that names these connections

File cabane_minou/soft/pins.h:

#ifndef PINS_HEADER_INCLUDED
#define PINS_HEADER_INCLUDED

#define PIN_IN_SW1_BUTTON             (40)
#define PIN_IN_SW2_BUTTON             (3)
#define PIN_IN_SW3_BUTTON             (5)
#define PIN_IN_PRESENCE_HAUT          (27)
#define PIN_IN_PRESENCE_TOUR_BAS      (37)
#define PIN_IN_PRESENCE_TOUR_HAUT     (39)
#define PIN_IN_CAPOT                  (32)
#define PIN_IN_PRESENCE_BAS           (36)
#define PIN_IN_TEMP_BAS               (38)
#define PIN_IN_TEMP_EXT               (42)

#define PIN_IN_MES_12V                (15)

#define PIN_IO1                       (7)
#define PIN_IO2                       (9)

#define PIN_OUT_LEDS_TOUR             (22)
#define PIN_OUT_LEDS_RES              (26)
#define PIN_OUT_LEDS_HAUT             (29)
#define PIN_OUT_LEDS_BAS              (31)
#define PIN_OUT_3V_ESP                (41)
#define PIN_OUT_LED1                  (43)
#define PIN_OUT_CMD_CHAUFFAGE         (2)
#define PIN_OUT_LED2                  (4)
#define PIN_OUT_LED3                  (6)
#define PIN_OUT_5V_LEDS_TOUR          (22)
#define PIN_OUT_5V_SER                (24)
#define PIN_OUT_5V_LEDS_RES           (26)
#define PIN_OUT_5V_LEDS_HAUT          (28)
#define PIN_OUT_5V_LEDS_BAS           (30)
#define PIN_OUT_LED_CAPOT_OUVERT      (34)

#endif
 

## Commit log

2021-01-31 Creation du projet contenant l'eclairage de la tour du minou
2021-01-31 image
2021-01-31 images
2021-02-01 Archivage du projet datalogger
2021-02-28 Creation carte cabane mino avec fritzing et kicad...
2021-03-28 Cabane minou Rev A0 envoyee
2021-05-01 Réalisation du logiciel: - Webservice pour acces aux LEDs haut/bas de la cabane - Détection de mouvement et allumage: Vert pour haut, Rouge pour bas - Mise à jour du soft a distance
    Correction schéma et PCB: Version B0:
    - Trous de fixation (2.2 mm de diametre). Ils étaient un peu trop gros
    - Simple diviseur pour l'entrée analogique: Non montées car déjà présentes sur NodeMcu
    - ...
2021-05-27 Creation du croquetuino - Commande de la vis sans fin sur sculpteo
    Mise au point cabane minou
2021-06-10 Deuxième fabrication: - Vis sans fin - Support vis - Support moteur
2021-12-07 Ménage: Fichiers pas utiles
2021-12-25 Amélioration de la cabane: - Ajout des animations - Ajout de scripts python
    NB: L'OTA ne marche plus car programme trop gros
2021-12-25 Mise au point
2022-03-19 Tel que fonctionne
2022-04-15 Amélioration gestion mesures Gestion du compteur de mvt capot
    + Reglage du PIR (temps mini / distance mini)
2022-04-15 Demo d'affichage des temperatures
2022-04-16 Affichage des autres valeurs de sensors
2022-04-16 Avec notification minou
2022-04-16 Amélioration
2022-04-16 Amélioration notification
2022-04-16 On vire les String qui ont l'air de fuiter...
2022-04-29 Ajout du MQTT
2022-12-03 Ajout json... dev a finir...
2022-12-03 Amelioration
2022-12-03 Stable
2022-12-05 Animation Noël 2022
    - 6h à 6h30 : tour en bleu
    - 6h30 à 7h00 : tour et cabane haut en bleu
    - 7h à 7h15 : tour animée, cabane haut alterne vert/bleu ttes les mins et cabane bas en rouge
    - 7h15 à 7h30 : tour animée, cabane haut alterne rouge/vert ttes les mins et cabane bas en bleu
    - 7h30 à 7h45 : tour animée, cabane haut alterne rouge/bleu ttes les mins et cabane bas en vert
    - 7h45 à 8h : tour animée, cabane haut animée et cabane bas en vert
2022-12-10 Garder la connexion Wifi
2022-12-11 Intégration de la lib Json (et remplacement methode à la main) Gestion commandes MQTT
2022-12-11 Fin du dev cmd mqtt + menage wdg
2022-12-11 Tour minou: Ajout du MQTT
    Correction limite setled sur cabane
2022-12-11 Ralentir les animations
2022-12-11 Essais mais tour NOK: Les LEDs ne s'allument plus !!
2022-12-11 Finalement ok (pb branchement)
2022-12-11 Amélioration anim (manquait une LED)
2023-12-16 Mise en service tour avec nouvelle IP + corr pb compil fastled
2024-10-27 Nouvelle version de Cabane minou (Rev C)
2024-10-27 Marquage future Version Rev C
2024-11-23 Design cabane minou "version 2024"
2024-11-27 MAJ version
2024-11-27 Amélioration design du PCB (contour) Adaptation à la boîte Ajout datasheets
2024-12-23 Renommage dossier hard Création nouvelle version de soft (pour la nouvelle carte 2024)
2024-12-23 Soft dans son dossier dédié
2024-12-24 Veille de Noël
2024-12-24 Ajout plage du matin Correction plage de soirée Ajout plus de filtrage detection de mouvement
2025-12-17 Début corrections suite utilisation en 2025...
2025-12-27 Carte de commande du tapis chauffant (230V)
2026-01-19 Modifs mineures: - Sérigraphie plus grosse - Commentaires sur schéma (consigne + D1 NM)
2026-01-26 R=1k pour LED
2026-01-29 Carte au format de la boite de dérivation
2026-01-30 Améliorations:
    - Isolation renforcée en coupant le PCB
    - Ajout de passage pour colliers de serrage des cables
    - Ajout diode en direct
    - Ajout découplages
    - Alignement grille 1mm
2026-01-30 Retouche dimension PCB 64mm x 64mm
2026-01-30 Création carte chauffage + ventillateur 12V
